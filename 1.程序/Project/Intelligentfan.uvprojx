# Keil uVision project Intelligentfan.uvprojx, settings and files
target Intelligentfan (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Intelligentfan +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Users;..\Hardware\TIM;..\Hardware\OLED;..\Hardware\sys;..\Hardware\delay;..\Hardware\key;..\Hardware\pwm;..\Hardware\DS18B20;..\Hardware\MENU;..\Hardware\gpio
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../../蓝桥杯省赛究极模板/Libraries/CMSIS/STARTUP/: startup_stm32f10x_hd.s
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group USER
    ../Users/: main.c stm32f10x_it.c stm32f10x_conf.h myconfig.c myconfig.h
  group HARDWARE
    ../Hardware/TIM/: tim.c
    ../Hardware/OLED/: oled.c oled.h oledfont.h
    ../Hardware/sys/: sys.c
    ../Hardware/delay/: delay.c
    ../Hardware/key/: bsp_key.c
    ../Hardware/pwm/: bsp_pwm.c
    ../Hardware/DS18B20/: bsp_ds18b20.c
    ../Hardware/MENU/: menu.c
    ../Hardware/gpio/: gpio.c
  group DOC
    ../DOC/: bsp_xx.c bsp_xx.h Read me.txt
